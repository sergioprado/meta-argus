require argus-image.bb

SUMMARY = "Argus Operating System base image for development"

IMAGE_FEATURES += "\
    debug-tweaks \
"
